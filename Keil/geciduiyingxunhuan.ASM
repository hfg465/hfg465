      ORG 0000H
	  AJMP MOOD
	  ORG 0100H
 MOOD:MOV SP,#30H
 MAIN:MOV A,#0FEH	;初始化循环小灯
      MOV R3,#01H	    ;初始化闪烁次数
	  MOV  R7,#1
START:MOV P1,A      ;开始循环
      LCALL DELAY   ;调用延时程序
	  MOV P1,#0FFH
	  LCALL DELAY
	  DJNZ R3,START
 NEXT:RL A
      INC R7
	  MOV 40H,R7
      MOV R3,40H
	  CJNE R7,#09H,LOOP
	  SJMP MAIN
 LOOP:SJMP START
DELAY:MOV R6,#44
 DEL0:MOV R5,#45
 DEL1:MOV R4,#46
 DEL2:NOP
      NOP
	  NOP
      DJNZ R4,DEL2
	  DJNZ R5,DEL1
	  DJNZ R6,DEL0
	  RET
	  END