# Keil uVision project shizhong.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: shizhong +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    C:/BaiduNet压缩包/单片机/51学习板/10、配套源码100多个/10、配套源码100多个/【实验104】DS1302时钟显示/DS1302 LCD1602显示/: main.c
